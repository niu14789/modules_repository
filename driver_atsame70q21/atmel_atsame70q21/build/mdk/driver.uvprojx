# Keil uVision project driver.uvprojx, settings and files
target debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.0
  cpu: IROM(0x00400000,0x00200000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: debug +hex
  AfterMake: output_debug.bat
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAME70_XPLD __SAME70Q21__ flash TRACE_LEVEL=4 NDEBUG  NOTRACE
  c include: ..\..\FreeRTOS\Source\include;..\..\FreeRTOS\Source\CMSIS_RTOS;..\..\FreeRTOS\Source\portable\RVDS\ARM_CM7\r0p1;..\..\Hardware\Driver\Include;..\..\Hardware\Utils\libboard\include;..\..\Hardware\Utils\libchip\include;..\..\Hardware\Utils\libchip;..\..\Hardware\Utils\libchip\include\same70;..\..\Hardware\Utils\libboard;..\..\Hardware\Utils\libfatfs\inc;..\..\Hardware\Utils\libfatfs;..\..\Hardware\Utils\libmemory;..\..\Hardware\Utils\libusb\include;..\..\Hardware\Utils\md5;..\..\IFC_Plane\System;..\..\Hardware\Utils\libchip\include\cmsis\CMSIS\Include;..\..\Hardware\Utils;..\..\Hardware\Driver\board;..\..\Hardware\Utils\libchip\include;..\..\Library\Other;..\..\Library\CANBus;..\..\Library\Link;..\..\Library\Link\mavlink;..\..\Library\Link\mavlink\common;..\..\Library\Sensor;..\..\Library\Mission;..\..\Library\Common;..\..\Library\Parameter;..\..\Hardware\Driver\Timer;..\..\Hardware\Driver\Emmc;..\..\Library\Log;..\..\Library\Channels;..\..\Hardware\Driver\fs;..\..\Hardware\Driver\pwm;..\..\..\..\common\file_system;D:\D200_GIT\D200\D200_fc\common\file_system;..\..\..\..\..\common\file_system
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x50000
  scatter file: ..\..\Hardware\Utils\libboard\resources_e70\mdk\debug.sct
  link misc: --keep __FS_*;--diag_suppress=L6314;--keep __FS_SHELL_*
  group system
    ../../d200_driver/system/: main.c
    ../../Hardware/Utils/libboard/resources_e70/mdk/: startup_sam.c
  group u_s_art
    ../../Hardware/Driver/Uart/: uart.c
  group pwm
    ../../Hardware/Driver/pwm/: pwm.c
  group spi
    ../../Hardware/Driver/Spi/: spi.c
  group libchip
    ../../Hardware/Utils/libchip/source/: exceptions.c mcan.c mpu.c pio.c pio_it.c pmc.c supc.c tc.c uart.c usart.c uart_dma.c usart_dma.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c efc.c flashd.c hsmci.c mcid_dma.c spi.c spi_dma.c twid.c twi.c pwmc.c
  group fs
    ../../../../common/file_system/: f_open.c f_shell.c fs_inode.c
target release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.0
  cpu: as above
  output: debug +hex
  AfterMake: output_release.bat
  AfterMake: release.bat
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c include: ..\..\FreeRTOS\Source\include;..\..\FreeRTOS\Source\CMSIS_RTOS;..\..\FreeRTOS\Source\portable\RVDS\ARM_CM7\r0p1;..\..\Hardware\Driver\Include;..\..\Hardware\Utils\libboard\include;..\..\Hardware\Utils\libchip\include;..\..\Hardware\Utils\libchip;..\..\Hardware\Utils\libchip\include\same70;..\..\Hardware\Utils\libboard;..\..\Hardware\Utils\libfatfs\inc;..\..\Hardware\Utils\libfatfs;..\..\Hardware\Utils\libmemory;..\..\Hardware\Utils\libusb\include;..\..\Hardware\Utils\md5;..\..\IFC_Plane\System;..\..\Hardware\Utils\libchip\include\cmsis\CMSIS\Include;..\..\Hardware\Utils;..\..\Hardware\Driver\board;..\..\Hardware\Utils\libchip\include;..\..\Library\Other;..\..\Library\CANBus;..\..\Library\Link;..\..\Library\Link\mavlink;..\..\Library\Link\mavlink\common;..\..\Library\Sensor;..\..\Library\Mission;..\..\Library\Common;..\..\Library\Parameter;..\..\Hardware\Driver\Timer;..\..\Hardware\Driver\Emmc;..\..\Library\Log;..\..\Library\Channels;..\..\Hardware\Driver\fs;..\..\Hardware\Driver\pwm;..\..\..\..\common\file_system;..\..\..\..\..\common\file_system
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x50000
  scatter file: ..\..\Hardware\Utils\libboard\resources_e70\mdk\release.sct
  link misc: --keep __FS_*;--diag_suppress=L6314;
