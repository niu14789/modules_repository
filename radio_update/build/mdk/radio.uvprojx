# Keil uVision project radio.uvprojx, settings and files
target debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.0
  cpu: IROM(0x00400000,0x00200000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: debug +hex
  AfterMake: output_debug.bat
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAME70_XPLD __SAME70Q21__ flash TRACE_LEVEL=4 NDEBUG  NOTRACE
  c include: ..\..\..\common\file_system;..\..\d200_driver\radio
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x50000
  scatter file: ..\..\Hardware\Utils\libboard\resources_e70\mdk\debug.sct
  link misc: --keep __FS_*;--diag_suppress=L6314;--keep __FS_SHELL_*
  group system
    ../../d200_driver/system/: main.c
    ../../Hardware/Utils/libboard/resources_e70/mdk/: startup_sam.c
  group radio
    ../../d200_driver/radio/: radio.c
  group fs
    ../../../common/file_system/: f_open.c f_shell.c fs_inode.c
target release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.0
  cpu: as above
  output: debug +hex
  AfterMake: output_release.bat
  AfterMake: release.bat
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c include: ..\..\..\common\file_system
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x50000
  scatter file: ..\..\Hardware\Utils\libboard\resources_e70\mdk\release.sct
  link misc: --keep __FS_*;--diag_suppress=L6314;
